# Keil uVision project MJ1_MCU.uvprojx, settings and files
target MJ1_MCU (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wiznet
  BeforeMake: pre_build.bat
  AfterMake: fromelf.exe --bin --output=wiznet.bin USER\Output\wiznet.axf
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: HSE_VALUE=12000000, _PRINTF_, _TCP_CLIENT_, _TRIGGER_IO_
  c misc: --gnu --c99
  c include: .\USER;.\CMSIS;.\LIB\inc;.\USER\shell\inc;.\USER\Ethernet;.\USER\Ethernet\W5500;.\USER\Ethernet\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c SysTick.c bsp_uart4.c pc_uart.c slt_uart.c cmd_proc.c slt_control.c
  group LIB
    ./LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./CMSIS/startup/arm/: startup_stm32f10x_md.s
  group SHELL
    ./USER/shell/src/: ansi.c ansi_port.c nr_micro_shell.c
  group ETHERNET
    ./USER/Ethernet/: socket.c wizchip_conf.c wizchip_init.c
    ./USER/Ethernet/W5500/: w5500.c
  group APP
    ./USER/Ethernet/APP/: dhcp.c dns.c
  group DOC
    ./DOC/protocol/: hex.txt
software components: CMSIS:CORE 6.1.0
